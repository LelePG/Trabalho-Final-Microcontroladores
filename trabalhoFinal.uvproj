# Keil uVision project trabalhoFinal.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: trabalho 7 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 leticia_TF.c definesIO.h lib_timers.h lib_7seg.h lib_keypad.h lib_lcd.h
